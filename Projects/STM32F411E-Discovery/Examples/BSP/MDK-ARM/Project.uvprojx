# Keil uVision project Project.uvprojx, settings and files
target STM32F411E-Discovery (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F411E-Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,USE_STM32F411E_DISCO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\inc;..\..\..\..\..\Drivers\BSP\STM32F411E-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Example/User
    ../Src/: main.c audio_record.c audio_play.c mems.c stm32f4xx_it.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f411xe.s
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/l3gd20/: l3gd20.c
    ../../../../../Drivers/BSP/Components/i3g4250d/: i3g4250d.c
    ../../../../../Drivers/BSP/Components/lsm303dlhc/: lsm303dlhc.c
    ../../../../../Drivers/BSP/Components/lsm303agr/: lsm303agr.c
    ../../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
  group Middlewares/STM32_Audio
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
  group Drivers/BSP/STM32F411E-Discovery
    ../../../../../Drivers/BSP/STM32F411E-Discovery/: stm32f411e_discovery_audio.c stm32f411e_discovery_accelerometer.c stm32f411e_discovery_gyroscope.c stm32f411e_discovery.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_i2s.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c
software components: CMSIS:CORE 4.1.0
