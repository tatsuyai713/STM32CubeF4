# Keil uVision project Project.uvprojx, settings and files
target STM32F401-Discovery (6070000::V6.7::.\ARMCLANG)
  device: STM32F401VCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F401-Discovery
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xC,USE_STM32F401_DISCO
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32F401-Discovery;..\..\..\..\Utilities\Log;..\..\..\..\Utilities\CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/STM32_Audio
    ../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
  group Example/MDK-ARM
    ./: startup_stm32f401xc.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/l3gd20/: l3gd20.c
    ../../../../Drivers/BSP/Components/lsm303dlhc/: lsm303dlhc.c
    ../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
  group Example/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
  group Drivers/BSP/STM32F401-Discovery
    ../../../../Drivers/BSP/STM32F401-Discovery/: stm32f401_discovery_accelerometer.c stm32f401_discovery.c stm32f401_discovery_audio.c stm32f401_discovery_gyroscope.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dac.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_usart.c stm32f4xx_hal_hcd.c stm32f4xx_hal_cortex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_cryp.c stm32f4xx_hal_exti.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2s.c stm32f4xx_hal_rng.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_ll_fmc.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_nand.c stm32f4xx_hal_sram.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_hash.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_irda.c stm32f4xx_hal_crc.c stm32f4xx_hal_tim.c stm32f4xx_hal_sai.c stm32f4xx_hal_eth.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_pccard.c
software components: CMSIS:CORE 5.3.0
