# Keil uVision project Project.uvprojx, settings and files
target STM32446E_Nucleo (6070000::V6.7::.\ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32446E_Nucleo
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F446xx
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: stm32f4xx_hal_msp.c main.c stm32f4xx_it.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rng.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_uart.c stm32f4xx_hal_rtc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_tim.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_dac.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_pcd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_eth.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2s.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_irda.c stm32f4xx_ll_usb.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc.c stm32f4xx_hal_exti.c stm32f4xx_hal_gpio.c stm32f4xx_hal_sai.c stm32f4xx_hal_nor.c stm32f4xx_hal_hash.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_cec.c stm32f4xx_hal_hash_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_pccard.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_hcd.c stm32f4xx_hal_smartcard.c
  group Example/MDK-ARM
    ./: startup_stm32f446xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
software components: CMSIS:CORE 5.3.0
