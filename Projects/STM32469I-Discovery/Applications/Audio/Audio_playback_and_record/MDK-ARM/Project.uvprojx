# Keil uVision project Project.uvprojx, settings and files
target STM32469I_DISCOVERY (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx,USE_STM32469I_DISCO_REVC,USE_USB_FS,USE_STM32469I_DISCOVERY,TS_MULTI_TOUCH_SUPPORTED
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32469I-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../Src/: waveplayer.c menu.c usbh_conf.c main.c ts_calibration.c waverecorder.c explorer.c stm32f4xx_it.c usbh_diskio_dma.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../../Drivers/BSP/Components/nt35510/: nt35510.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
  group Application/MDK-ARM
    ./: startup_stm32f469xx.s
  group Middlewares/PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_scsi.c usbh_msc_bot.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ioreq.c usbh_ctlreq.c usbh_pipes.c usbh_core.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
  group Drivers/BSP/STM32469I-Discovery
    ../../../../../../Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery_audio.c stm32469i_discovery.c stm32469i_discovery_sdram.c stm32469i_discovery_lcd.c stm32469i_discovery_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Doc
    ../: readme.txt
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2s_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_tim.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_hcd.c stm32f4xx_hal_uart.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_i2s.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_sdram.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_flash.c stm32f4xx_hal_sai.c stm32f4xx_hal.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim_ex.c
software components: CMSIS:CORE 4.3.0
