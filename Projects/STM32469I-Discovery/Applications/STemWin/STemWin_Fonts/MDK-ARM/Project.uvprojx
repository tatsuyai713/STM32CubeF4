# Keil uVision project Project.uvprojx, settings and files
target STM32469I_DISCOVERY (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx,USE_STM32469I_DISCO_REVC,USE_STM32469I_DISCOVERY
  c include: ../Core/Inc;../STemWin/App/generated/fonts;../STemWin/App/generated/images;../STemWin/Target;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32469I-Discovery;../../../../../../Drivers/BSP/Components/otm8009a;../../../../../../Middlewares/ST/STemWin/inc;../STemWin/Target
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/nt35510/: nt35510.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
  group Middlewares/STemWin/OS
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Application/User/Core
    ../Core/Src/: stm32f4xx_it.c main.c
  group Application/MDK-ARM
    ./: startup_stm32f469xx.s
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM4_wc16_ARGB.a
  group Drivers/BSP/STM32469I-Discovery
    ../../../../../../Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Doc
    ../: readme.txt
  group Middlewares/STemWin/Target
    ../STemWin/Target/: LCDConf.c GUIConf.c
  group Application/User/STemWin
    ../STemWin/App/: font_app.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_sdram.c stm32f4xx_hal_dsi.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2s_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_i2s.c stm32f4xx_hal_tim_ex.c
software components: CMSIS:CORE 4.3.0
