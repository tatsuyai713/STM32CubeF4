# Keil uVision project Project.uvprojx, settings and files
target STM32469I_DISCO (ARM-ADS)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x2000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32469I_DISCO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx,USE_STM32469I_DISCO,USE_STM32469I_DISCO_REVC,TS_MULTI_TOUCH_SUPPORTED
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM32469I-Discovery;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Utilities\Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_ll_fmc.c stm32f4xx_hal_i2s.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sai.c
  group Example/MDK-ARM
    ./: startup_stm32f469xx.s
  group Drivers/BSP/STM32469I_DISCO
    ../../../../../Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery_qspi.c stm32469i_discovery_eeprom.c stm32469i_discovery.c stm32469i_discovery_lcd.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c stm32469i_discovery_sd.c stm32469i_discovery_audio.c
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: sdram.c sd.c lcd.c stm32f4xx_it.c ts_calibration.c log.c qspi.c eeprom.c sdram_dma.c audio_play.c animation.c audio_rec.c touchscreen.c main.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/nt35510/: nt35510.c
    ../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares\PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
software components: CMSIS:CORE 4.1.0
