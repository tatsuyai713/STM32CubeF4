# Keil uVision project Project.uvprojx, settings and files
target STM32429I_EVAL (6070000::V6.7::.\ARMCLANG)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32429I_EVAL
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM324x9I_EVAL;..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\Drivers\BSP\Components\ov2640;..\..\..\..\Drivers\BSP\Components\stmpe1600;..\..\..\..\Drivers\BSP\Components\stmpe811;..\..\..\..\Drivers\BSP\Components\ts3510;..\..\..\..\Drivers\BSP\Components\wm8994;..\..\..\..\Utilities\Log;..\..\..\..\Utilities\Fonts;..\..\..\..\Utilities\CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Middlewares/ST/STM32_Audio/Addons/PDM
    ../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
  group Drivers/BSP/STM324x9I_EVAL
    ../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval_io.c stm324x9i_eval_sdram.c stm324x9i_eval_sd.c stm324x9i_eval_audio.c stm324x9i_eval_ts.c stm324x9i_eval_lcd.c stm324x9i_eval_camera.c stm324x9i_eval_sram.c stm324x9i_eval_nor.c stm324x9i_eval.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Example/MDK-ARM
    ./: startup_stm32f429xx.s startup_stm32f439xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_sram.c stm32f4xx_hal_sai.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_nand.c stm32f4xx_hal_flash.c stm32f4xx_hal_ltdc.c stm32f4xx_hal.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_cryp.c stm32f4xx_hal_hash.c stm32f4xx_hal_dac.c stm32f4xx_hal_irda.c stm32f4xx_hal_rtc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_usart.c stm32f4xx_ll_fmc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_exti.c stm32f4xx_hal_gpio.c stm32f4xx_ll_usb.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_spi.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_adc.c stm32f4xx_hal_pccard.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_sai_ex.c
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/ts3510/: ts3510.c
    ../../../../Drivers/BSP/Components/exc7200/: exc7200.c
    ../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
    ../../../../Drivers/BSP/Components/ov2640/: ov2640.c
    ../../../../Drivers/BSP/Components/wm8994/: wm8994.c
    ../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Example/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
target STM32439I_EVAL (6070000::V6.7::.\ARMCLANG)
  device: STM32F439NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32439I_EVAL
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F439xx,USE_STM324x9I_EVAL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.3.0
